# Repository shengwen-tw/nixie-clock

File readme:

###############################################
# Project name : Nixie Clock                  #
# Developer : Shengwen (l1996812@gmail.com)   #
# Platform : Arduino                          #
###############################################

Description:
Nixie Tube is fascinating display, just like an art.
To combine with other stuffs, I can create a beautiful clock!

Welcome to contact with me to share your ideas!

## KiCad design circuit/commertial_design_ver3/display_board/nixie_control_board.kicad_pcb

Board: 2 copper layers, 200.0 x 63.0 mm, 13 parts (0 on the bottom side), 22 nets.

Parts:
P1: CONN_02X01; Pin_Header_Straight_2x01
P5: CONN_01X08; Pin_Header_Straight_2x04
P6: CONN_01X12; Pin_Header_Straight_2x06
SW3: SW_PUSH; SW_PUSH-12mm
U10, U11, U12, U13, U14, U15, U16, U17: IN-14
e REF**: 1pin

Connections:
unnamed: P1.1, SW3.2
unnamed: P1.2, SW3.1
anode1: P5.8, U10.1
anode2: P5.7, U12.1
anode3: P5.6, U14.1
anode4: P5.5, U16.1
anode5: P5.4, U11.1
anode6: P5.3, U13.1
anode7: P5.2, U15.1
anode8: P5.1, U17.1
cathode0: P6.1, U10.12, U11.12, U12.12, U13.12, U14.12, U15.12, U16.12, U17.12
cathode1: P6.10, U10.3, U11.3, U12.3, U13.3, U14.3, U15.3, U16.3, U17.3
cathode2: P6.9, U10.4, U11.4, U12.4, U13.4, U14.4, U15.4, U16.4, U17.4
cathode3: P6.8, U10.5, U11.5, U12.5, U13.5, U14.5, U15.5, U16.5, U17.5
cathode4: P6.7, U10.6, U11.6, U12.6, U13.6, U14.6, U15.6, U16.6, U17.6
cathode5: P6.6, U10.7, U11.7, U12.7, U13.7, U14.7, U15.7, U16.7, U17.7
cathode6: P6.5, U10.8, U11.8, U12.8, U13.8, U14.8, U15.8, U16.8, U17.8
cathode7: P6.4, U10.9, U11.9, U12.9, U13.9, U14.9, U15.9, U16.9, U17.9
cathode8: P6.3, U10.10, U11.10, U12.10, U13.10, U14.10, U15.10, U16.10, U17.10
cathode9: P6.2, U10.11, U11.11, U12.11, U13.11, U14.11, U15.11, U16.11, U17.11
cathode_comma_left: P6.11, U10.2, U11.2, U12.2, U13.2, U14.2, U15.2, U16.2, U17.2
cathode_comma_right: P6.12, U10.13, U11.13, U12.13, U13.13, U14.13, U15.13, U16.13, U17.13

## KiCad design circuit/commertial_design_ver3/control_board/nixie_control_board.kicad_pcb

Board: 2 copper layers, 200.0 x 66.0 mm, 73 parts (1 on the bottom side), 78 nets.

Parts:
BT1: CR2032; CR2032H
C1: 182p; C_0805_HandSoldering
C2: 100uf/16v; c_elec_6.3x5.3
C3, C5: 680uf/16v; C_Radial_D10_L16_P5
C4, C10, C12, C13, C15: 0.1uf; C_0805_HandSoldering
C6, C7: 33uf/250v; C_Radial_D13_L21_P5
C8, C9: 22pf; C_0805_HandSoldering
C11, C16: 10uf; C_0805_HandSoldering
C14: 330pf; C_0805_HandSoldering
CON1: BARREL_JACK; JACK_ALIM
D1: 1N4148; Diode_DO-35_SOD27_Horizontal_RM10
D2: 1N5819; Diode_DO-41_SOD81_Horizontal_RM10
D3: FR154; Diode_DO-41_SOD81_Horizontal_RM10
D4: D_Schottky; Diode_DO-35_SOD27_Horizontal_RM10
IC1: ATMEGA328P-A; TQFP-32_7x7mm_Pitch0.8mm
L1, L3: 220uh; INDUCTOR_V
L2: 22uh; INDUCTOR_V
L4: 1uh; INDUCTOR_V
P1: CONN_01X08; Pin_Header_Straight_2x04
P2: CONN_02X01; Pin_Header_Straight_2x01
P3: CONN_01X12; Pin_Header_Straight_2x06
P4: CONN_01X04; Pin_Header_Straight_1x04
P6: CONN_02X03; Pin_Header_Straight_2x03
Q1: 2SB647; TO-92_Inline_Narrow_Oval
Q2: 2SK3611; TO-220_Neutral123_Vertical
Q3, Q4: MPSA42; TO-92_Inline_Narrow_Oval
Q5: BC557; TO-92_Inline_Narrow_Oval
R1, R2, R20, R21: 0.5ohm; R_1206_HandSoldering
R3, R4, R19, R23: 1k ohm; R_1206_HandSoldering
R5: 620ohm; R_1206_HandSoldering
R6: 100k ohm; R_1206_HandSoldering
R7: 750 ohm; R_1206_HandSoldering
R8, R12: 330ohm; R_1206_HandSoldering
R9: 5.1k ohm; R_1206_HandSoldering
R10: 33K ohm; R_1206_HandSoldering
R11: 33k ohm; R_1206_HandSoldering
R15: 10k ohm; R_1206_HandSoldering
R16, R17: 4.7k ohm; R_1206_HandSoldering
R18: 1K ohm; R_1206_HandSoldering
R22: 3k ohm; R_1206_HandSoldering
SP1: SPEAKER; PINHEAD1-2
SW1: SW_PUSH; SW_SPST_PTS645
U1, U2: MC34063A; SO-8
U3, U4, U6, U7: TLP521; DIP-8_W7.62mm
U5: HEF4028; DIP-16_W7.62mm
U8: 74L147; DIP-16_W7.62mm
U9: DS3231; SO-16-W
U10: LM1117-3.3; SOT-223
U11: hc06
U18: DFPlayer
Y1: 16MHZ; Crystal_HC49-U_Vertical

Connections:
/RTC/5V: C4.1, C5.1, C11.1, C12.1, C13.2, C15.1, IC1.4, IC1.6, IC1.18, IC1.20, L4.2, P2.1, P6.2, R15.2, R16.1, R17.1, U5.16, U8.5, U9.2, U10.3, U18.1
/RTC/GND: BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, CON1.2, CON1.3, D2.2, IC1.3, IC1.5, IC1.21, P4.2, P6.6, Q1.2, Q2.3, Q3.1, Q4.1, Q5.1, R3.2, R7.2, R8.1, R12.1, R23.2, SW1.1, U1.4, U2.4, U5.8, U8.12, U9.5, U9.6, U9.7, U9.8, U9.9, U9.10, U9.11, U9.12, U9.13, U10.1, U11.13, U11.22, U18.7, U18.10
/RTC/I2C_SCL: IC1.28, R17.2, U9.16
/RTC/I2C_SDA: IC1.27, R16.2, U9.15
/nixie_control/3V3: C16.1, U10.2, U10.4, U11.12
/nixie_control/170V: C7.1, L2.2, R9.2
/power_supply/12V: C2.1, C10.1, CON1.1, R1.1, R2.1, R20.1, R21.1, U1.6, U2.6
Crystal1: C8.1, IC1.7, Y1.1
Ctystal2: C9.1, IC1.8, Y1.2
Digit_A0: IC1.26, U5.10
Digit_A1: IC1.11, U5.13
Digit_A2: IC1.10, U5.12
Digit_A3: IC1.9, U5.11
Font_A: IC1.17, P6.3, U8.3
Font_B: IC1.16, P6.1, U8.6
Font_C: IC1.15, P6.4, U8.7
Font_D: IC1.14, U8.4
MP3_RX: IC1.12, R19.2
MP3_TX: IC1.13, R18.2
Mode_button: IC1.32, P2.2, R12.2
unnamed: BT1.1, U9.14
unnamed: C1.1, U1.3
unnamed: C3.1, L3.2, L4.1, R22.2
unnamed: C6.1, D3.1, L2.1, R6.1
unnamed: C14.1, D4.1, Q5.3
unnamed: D1.1, Q1.1, Q2.1
unnamed: D1.2, Q1.3, R3.1, U2.2
unnamed: D2.1, L3.1, U1.2
unnamed: D3.2, L1.2, Q2.2
unnamed: D4.2, Q5.2, U2.3
unnamed: L1.1, R1.2, R2.2, R4.1, R5.1, U2.7
unnamed: P1.1, U7.7
unnamed: P1.2, U7.5
unnamed: P1.3, U6.7
unnamed: P1.4, U6.5
unnamed: P1.5, U4.7
unnamed: P1.6, U4.5
unnamed: P1.7, U3.7
unnamed: P1.8, U3.5
unnamed: P3.1, U8.2
unnamed: P3.2, U8.1
unnamed: P3.3, U8.10
unnamed: P3.4, U8.11
unnamed: P3.5, U8.14
unnamed: P3.6, U8.13
unnamed: P3.7, U8.9
unnamed: P3.8, U8.8
unnamed: P3.9, U8.15
unnamed: P3.10, U8.16
unnamed: Q3.3, R10.1
unnamed: Q4.3, R11.1
unnamed: R4.2, U2.1
unnamed: R5.2, U2.8
unnamed: R6.2, R7.1, U2.5
unnamed: R8.2, U3.2, U3.4, U4.2, U4.4, U6.2, U6.4, U7.2, U7.4
unnamed: R9.1, U3.6, U3.8, U4.6, U4.8, U6.6, U6.8, U7.6, U7.8
unnamed: R18.1, U18.2
unnamed: R19.1, U18.3
unnamed: R20.2, R21.2, U1.1, U1.7, U1.8
unnamed: R22.1, R23.1, U1.5
unnamed: SP1.1, U18.8
unnamed: SP1.2, U18.6
unnamed: U3.1, U5.14
unnamed: U3.3, U5.3
unnamed: U4.1, U5.15
unnamed: U4.3, U5.2
unnamed: U5.1, U6.3
unnamed: U5.4, U7.1
unnamed: U5.6, U6.1
unnamed: U5.7, U7.3
Reset: IC1.29, P6.5, R15.1, SW1.2
USART_RX: IC1.30, P4.3, U11.1
USART_TX: IC1.31, P4.4, U11.2
_cathode_comma_left: P3.11, R10.2
_cathode_comma_right: P3.12, R11.2
dfplayer_state: IC1.1, U18.16
left_comma: IC1.24, Q3.2
right_comma: IC1.23, Q4.2

## KiCad design circuit/control_board/nixie-clock.kicad_pcb

Board: 2 copper layers, 102.7 x 51.6 mm, 46 parts (0 on the bottom side), 62 nets.

Parts:
1PIN, 1PIN#2: P***; 1pin
C1: 100 uf; C1V7
C2, C3: 0.1 uf; C1
C4, C5: 22pf; C1
IC1: ATMEGA328-P; DIP-28__300_ELL
OSHW_COPPER_10MM: VAL**; OSHW_COPPER_10MM
P1, P2, P7, P8, P9, P10: CONN_2; PIN_ARRAY_2X1
P3, P4: CONN_4; PIN_ARRAY_4x1
P5: CONN_8; pin_array_4x2
P6: CONN_12; pin_array_6x2
Q1, Q2, Q3: NPN; TO92
R1: 100k ohm; R1
R2, R3, R4, R5, R6, R7: 330ohm; R1
R8, R9: 4.7k ohm; R1
R10: 10k ohm; R1
R11, R12: 1.8kohm; R1
SW1, SW2, SW3: SW_PUSH; PIN_ARRAY_2X1
SW4: SW_PUSH; SW_PUSH_SMALL
U1: LM7805; LM78XX
U2, U3, U4, U7: TLP521; DIP-8__300_ELL
U5: HEF42028; DIP-16__300_ELL
U6: K155ID1; DIP-16__300_ELL
X1: 16MHZ; HC-49V

Connections:
5V: C3.1, IC1.7, IC1.20, IC1.21, P3.4, P4.4, P9.1, P10.1, SW1.1, SW2.1, SW3.1, SW4.1, U1.VO, U5.16, U6.5
170V: Q2.3, R1.2
Adjust button: IC1.5, R3.1, SW2.2
Bluetooth/FTDI Rx: IC1.3, P3.1, P4.1
Bluetooth/FTDI Tx: IC1.2, P3.2, P4.2
Brightness: IC1.15, Q2.2
Crystal1: C4.1, IC1.9, X1.2
Crystal2: C5.1, IC1.10, X1.1
Digit A0: IC1.14, U5.10
Digit A1: IC1.13, U5.13
Digit A2: IC1.12, U5.12
Digit A3: IC1.11, U5.11
Font A: IC1.19, U6.3
Font B: IC1.18, U6.6
Font C: IC1.17, U6.7
Font D: IC1.16, U6.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.8, IC1.22, P1.2, P2.2, P3.3, P4.3, P9.2, P10.2, Q1.1, Q3.1, R2.2, R3.2, R4.2, R5.1, R6.2, R7.2, R10.2, U1.GND, U5.8, U6.12
I2C SCL: IC1.28, R9.1
I2C SDA: IC1.27, R8.1
Left dot: IC1.24, Q3.2
MP3 Rx: IC1.26, R7.1, R12.1
MP3 Tx: IC1.25, R6.1, R11.1
Mode button: IC1.4, R4.1, SW3.2
unnamed: C1.1, C2.1, P1.1, U1.VI
unnamed: P2.1, R1.1
unnamed: P5.1, U7.7
unnamed: P5.2, U7.5
unnamed: P5.3, U4.7
unnamed: P5.4, U4.5
unnamed: P5.5, U3.7
unnamed: P5.6, U3.5
unnamed: P5.7, U2.7
unnamed: P5.8, U2.5
unnamed: P6.1, U6.16
unnamed: P6.2, U6.15
unnamed: P6.3, U6.8
unnamed: P6.4, U6.9
unnamed: P6.5, U6.13
unnamed: P6.6, U6.14
unnamed: P6.7, U6.11
unnamed: P6.8, U6.10
unnamed: P6.9, U6.1
unnamed: P6.10, U6.2
unnamed: P6.11, Q1.3
unnamed: P6.12, Q3.3
unnamed: P7.1, R11.2
unnamed: P7.2, R12.2
unnamed: P8.1, R8.2
unnamed: P8.2, R9.2
unnamed: Q2.1, U2.6, U2.8, U3.6, U3.8, U4.6, U4.8, U7.6, U7.8
unnamed: R5.2, U2.2, U2.4, U3.2, U3.4, U4.2, U4.4, U7.2, U7.4
unnamed: U2.1, U5.14
unnamed: U2.3, U5.3
unnamed: U3.1, U5.15
unnamed: U3.3, U5.2
unnamed: U4.1, U5.6
unnamed: U4.3, U5.1
unnamed: U5.4, U7.1
unnamed: U5.7, U7.3
Reset: IC1.1, R10.1, SW4.2
Right dot: IC1.23, Q1.2
Search button: IC1.6, R2.1, SW1.2

## KiCad design circuit/DS1307_module/ds1307_board.kicad_pcb

Board: 2 copper layers, 53.0 x 23.9 mm, 6 parts (1 on the bottom side), 7 nets.

Parts:
BT1: BATTERY; CR2032H
C1: C; C1
OSHW_COPPER_10MM: VAL**; OSHW_COPPER_10MM
P1: CONN_4; PIN_ARRAY_4x1
U1: DS1307; DIP-8__300_ELL
X1: CRYSTAL; QMONTRE

Connections:
5V: C1.1, P1.1, U1.8
GND: BT1.2, C1.2, P1.2, U1.4
unnamed: U1.2, X1.1
unnamed: BT1.1, U1.3
unnamed: U1.1, X1.2
SCL: P1.3, U1.6
SDA: P1.4, U1.5

## KiCad design circuit/power_supply/power-supply.kicad_pcb

Parts:
2SB647: PNP
2SK2611: MOSFET-N
BT1: BATTERY
C1: 100uf/16v
C2: 1500pf
C3: 33v/250v
C4: 33uf/250v
D1: 1N4148
D2: FR157
L1: 220uh
L2: 22uh
P1: CONN_2
R1, R2: 1k ohm
R3: 620 ohm
R4: 100k ohm
R5: 760 ohm
R6, R7: 0.5 ohm
U1: MCS34063A

Connections:
unnamed 0: 2SB647.3 (C), 2SK2611.S, BT1.2, C1.2, C2.2, C3.2, C4.2, P1.2, R2.2, R5.2, U1.4 (GND); also elsewhere on the board
unnamed: R3.2, U1.8 (Cd)
unnamed: C3.1, D2.2 (K), L2.1, R4.1
unnamed: 2SK2611.D, D2.1 (A), L1.2
unnamed 4: 2SB647.1 (E), 2SK2611.G, D1.2 (K); also elsewhere on the board
unnamed: C4.1, L2.2, P1.1
unnamed: R1.2, U1.1 (Cs)
unnamed 7: 2SB647.2 (B), D1.1 (A), R2.1, U1.2 (Es); also elsewhere on the board
unnamed: L1.1, R1.1, R3.1, R6.1, R7.1, U1.7 (Si)
unnamed: R4.2, R5.1, U1.5 (INV)
unnamed: BT1.1, C1.1, R6.2, R7.2, U1.6 (Vcc)
unnamed: C2.1, U1.3 (Ct)

Board: 2 copper layers, 66.0 x 38.7 mm, 21 parts (0 on the bottom side), 12 nets.

Other parts of the board:
OSHW_COPPER_10MM: VAL**; OSHW_COPPER_10MM
PNP1: 2SB647; TO92-123

Their connections:
unnamed 0: PNP1.2; also elsewhere on the board
unnamed 4: PNP1.1; also elsewhere on the board
unnamed 7: PNP1.3; also elsewhere on the board

File BOM.md:

Power Supply Board
======================

**Resistor**

0.5 ohm * 2

620 ohm * 3

760 ohm * 1

1k ohm * 2

100k ohm * 1

**Electrolytic capacitor**

100uf/16v * 1

33uf/250v * 2

**Mylar capacitor**

1500pf * 1

**Inductor**

22 uf * 1

220 uh * 1

**Diode**

1N4148 * 1

FR157 * 1

**IC**

MC34063A * 1

*BJT**

2SB647(PNP) * 1

**MOSFET**

2SK2611(N-Type) * 1

Display Board
======================

**Nixie tube**

IN-14 * 8

Control Board
======================

**Resistor**

330 ohm * 6

1.8k ohm * 2

4.7k ohm *2

10k ohm * 1

30k ohm * 1

**Electrolytic capacitor**

100uf/16v * 

**Ceramic capacitors**

0.1uf * 2

22pf * 2

**IC**

LM7805 * 1

ATMega328p * 1

TLP521 * 4

HEF428 * 1

K155ID1 * 1

**BJT**

MPSA9(PNP) * 3

**Quartz crystal oscillator**

16MHZ * 1

**Switch**

(2p, 6x6x4.3mm) * 1

**Pin**

(1 * 2 array) * 5

(1 * 4 array) * 2

(2 * 4 array) * 1

(2 * 6 array) * 1

## KiCad design circuit/commertial_design/tube/nixie_control_board.kicad_pcb

Parts:
P1, P2: CONN_01X04; Pin_Header_Straight_1x04
P3: CONN_01X05; Pin_Header_Straight_1x05
U10: IN-14

Connections:
anode: P3.3, U10.1 (Anode)
cathode0: P3.5, U10.12 (Cathode_0)
cathode1: P3.1, U10.3 (Cathode_1)
cathode2: P2.4, U10.4 (Cathode_2)
cathode3: P2.3, U10.5 (Cathode_3)
cathode4: P2.2, U10.6 (Cathode_4)
cathode5: P2.1, U10.7 (Cathode_5)
cathode6: P1.1, U10.8 (Cathode_6)
cathode7: P1.2, U10.9 (Cathode_7)
cathode8: P1.3, U10.10 (Cathode_8)
cathode9: P1.4, U10.11 (Cathode_9)
cathode_comma_left: P3.2, U10.2 (Cathode_Comma_Left)
cathode_comma_right: P3.4, U10.13 (Cathode_Camma_Right)

Board: 2 copper layers, 19.4 x 19.4 mm, 4 parts (3 on the bottom side), 13 nets.

## Code that names these connections

File firmware/firmware/nixie_clock/pindef.cpp:

#include <Arduino.h>

#include "pindef.h"

//K155IDI
int pin_font_a = 13, pin_font_b = 12, pin_font_c = 11, pin_font_d = 10;

int pin_font_left_dot = A1, pin_font_right_dot = A0;

//HEF4028
int pin_tube_select_a0 = A3, pin_tube_select_a1 = 7, pin_tube_select_a2 = 6, pin_tube_select_a3 = 5;

int pin_brightness = 9;

//Buttons
int pin_play_button = 4, pin_adjust_button = 3, pin_mode_button = 2;

//MP3
int mp3_rx = 8, mp3_tx = 9, mp3_state = 3;

## Commit log (part)

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2013-11-09 implemented basic time function and display it on seven segment display
2013-11-09 fixed typo in readme
2013-11-10 support the mode switch button
    *Also fixed the date issue in function sort_to_digit()
2013-11-10 support 12/24 hour format and a display mode button
    (1)Added a new button to do display mode switch
    (2)Support 12/24 hour format
    (3)Added "debug.cpp" which provide serial I/O for code debugging
2013-11-10 added the missing debug.cpp file
2013-11-10 created the readme.md to replace the old readme
2013-11-11 implemented display blinking feature and named the three buttons
    (1)Implemented display blinking feature
    (2)Named three buttons and its event handler
    |-btn_search -> btn_search_event()
    |-btn_adjust -> btn_adjust_event()
    |-btn_mode -> btn_mode_event()
2013-11-12 added the dot point at the time mode and fixed some bugs
    (1)Added the dot point related code
    (2)Improved the blur issue which cause on seven segment display
    (3)Fixed the bug that the mode button is not able to switch to other digits on setting mode
2013-11-13 modularized the button event and added some actions at setting mode
2013-11-13 interrupt blinking while user press the search button at setting mode
2013-11-17 added function is_blink_digit()
    *TODO:Blink several digit at a time
2013-11-18 wrote the explanation of arduino libraries
    (1)Modified the description of the project
    (2)Wrote the explanation of arduino libraries
2013-11-18 fixed the wrong markdown syntax of the readme file
2013-11-19 start to rewrite all the code in new architecture
2013-11-20 created the circuit project and added arduino-uno in libraries
2013-11-20 wrote the explanation about the circuit
2013-11-21 support better digit blink implemented by using timer
    *Support multiple digits to blink at the same time (Also improve the writing skill)
    *Added clock test code to test while the DS1307 time chip is broken
2013-11-21 completed the basic architecture of the button
    *TODO:Implement all the button event handlers
2013-11-22 finish rewrite the button events
    *TODO:Implement the clock setting
2013-11-22 fixed the wrong kicad command in readme
2013-11-22 added the MIT license
2013-11-23 support switch to other digits during clock setting mode
2013-11-23 support increase the number of the time in range
    *Only support year, hour, minute, second.
    (Month and day need to add more conditions)
2013-11-27 added the time structure and support to switch to the alarm mode
    (1)Replace the time related variable to time structure.
    (2)Support switching the mode to the alarm mode, but not implement the detail yet.
2013-11-27 updated the information of the platform
2013-11-28 fully support adjust the setting of the alarm
    *TODO: Arrange the mess code
    *The alarm now only provide the setting function, other details need to implement
2013-12-02 updated the readme about the required libraries (Music module)
2013-12-03 imported the music player module
    *FIXME:The functions is basiclly finished, but it doesn't work
    *Implemented the alarm time checking function
2013-12-03 fixed the music broadcast issue
    *The alarm can use the music function from now
    (1)FIXME:The function play_music() still have some problems need to improve
    (2)Replaced the serial event for testing the music function
2013-12-03 adjusted the initial time of alarm to 12:00:00
2013-12-07 added PCB board Nixie-display-board and Nixie-Power-Supply
2013-12-07 expanded the size of the Nixie-Power-Supply board
2014-02-01 added directory "control_board"
2014-02-01 power_supply: filled the value in all components
2014-02-01 power_supply: replaced the components of Vcc/Ground
2014-02-01 power_supply: created the net file
2014-02-02 power_supply :imported footprint type "TO-247"
2014-02-02 Remove some rubbish kicad project files
2014-02-02 power_supply: completed the component type selection
    *Import the TO-247 footprint into the project setting
    *Updated the net file
    *Created the PCB board file
2014-02-03 power_supply: imported the TO-247 3D model
2014-02-03 power_supply: generated the routing files
2014-02-03 power_supply: completed the nixie tube power supply circuit
2014-02-03 power_supply: increased the size of the track line
2014-02-03 power_supply: added some space between two track lines
2014-02-04 power_supply: added two resistors into the circuit
2014-02-04 renamed directory "PCB board" to "display_board"
2014-02-04 created the BOM list
2014-02-04 power_supply: imported the OSHW logo and adjusted the route
2014-02-07 control_board: removed the unused test circuit
2014-02-07 control_board: added the basic ATMega328p circuit
2014-02-11 power_supply: expanded the pad size
2014-02-11 power_supply:cmp: changed the pnp package type "TO-92-123"
2014-02-11 extra:moved the mods into the new folder "footprints_doc"
2014-02-11 removed the extra_mod, it can be found in the default libraries
2014-02-16 power_supply: fixed the wrong TO-92 ECB footprint issue
2014-06-14 Add new component "TLP521-2"
2014-06-14 Create new component "K155ID1"
2014-06-14 Create new component "HEF4028B"
2014-06-14 Finish the basic nixie tube control circuit
2014-06-22 Fix the HEF42028 circuit (control board, to anode pin)
2014-06-22 Control board: add the mp3 tx/rx port circuit
2014-06-22 Add the pinout picture
2014-06-22 Add the atmega168 pinout picture
2014-06-23 Control board: connect the wire of the bluetooth module
2014-06-27 Control board: generate the net file
2014-06-27 Control board: Set some component footprint data
2014-06-27 Control board: Clear the messy circuit, and modularize the AC adapter
2014-06-27 Control board: Modularize the circuit of nixie tube power supply (170v)
2014-06-27 Control board: Modularize the circuit of mp3 module
2014-06-27 Control board: Modularize the circuit of bluetooth and fix mp3 module's circuit
2014-06-27 Control Board: Fix the wrong pin direction of "TLP521"
2014-06-27 Control board: Modularize the circuit of reset button and crystal
2014-06-27 Control board: Modularize the circuit of nixie tube anode pin
2014-06-27 Control board: Modularize the circuit of nixie tube cathode pin
2014-06-27 Control board: Create the circuit for DS1307 time module
2014-06-27 Control board: Fill in the value of resistor
2014-06-27 Control board: Create the circuit for FTDI
2014-06-30 Control board: Remove a connecter
2014-06-30 Control board: Annoate the circuit
2014-06-30 Control board: Set the package type of all components
2014-07-01 Control board: Fix the wrong package type of component
2014-07-01 Control board: Add the missing pcb file
2014-07-01 Control board: Create the PCB zone
2014-07-01 Control board: Connect 170v power with TLP521
2014-07-01 Control board: Adjust the wire
2014-07-01 Control board: Add the brightness control circuit
2014-07-01 Control board: Update the PCB placement
2014-07-01 Control board: Autoroute the wire
2014-07-02 COntrol board: Fix the mp3 player voltage divided circuit error
2014-07-02 Control board: Fix the wrong pin of "K155ID1"
2014-07-02 Control Board: Rearrange the position of the PCB board
2014-07-02 Control board: Add two 2*1 pin array for 5v power
2014-07-02 Add the pinout picutre of the control board
2014-07-02 DS1307 board: Create the DS1307 board project
2014-07-02 DS1307 board: Set the package type of all components
2014-07-02 DS1307 board: Finish design and route the board
2014-07-02 DS1307 board: Add some logo
2014-07-24 Add nixie tube's picture
2014-08-03 Control board: Add the board edge
2014-08-03 Power supply board: Add the board edge
2014-08-03 Power supply board: Create the geber file
2014-08-03 Control board: Create the geber file
2014-08-03 DS1307 board: Create the geber file
2014-08-03 COntrol board: Fix the pad shape
2014-08-04 Update the nixie-clock.kicad_pcb to the Kicad EDA4 format
2014-08-04 Control board: Remove the aux_axis
2014-08-04 Control board: Add two screw drill hole
2015-02-16 Control board: Remove the coper zone and adjust the track line
2015-02-17 Control board: Adjust track line, pad size and via size
2015-02-18 Remove the coper zone
2015-02-18 Power supply board: Arrange the label
2015-02-18 Power supply board: Arrange the track line
2015-02-18 DS1307 board: Remove the coper zone, adjust the track line
2015-02-22 DS1307 board: Add a new label
2015-02-22 Add the pinout picture of power supply board
2015-02-24 Control board: Optimize some auto-route layout
2015-02-24 DS1307 module: Optimize the layout to only single side
2015-04-17 Control board: Optimize TLP521 route
2015-04-17 Control board: Fix the missing net
2015-04-17 Control board: Fix the FTDI Rx net and optimize some route
2015-04-17 Control board: Optimize the route
2015-04-17 Control board: Optimize FTDI route
2015-04-19 Control board: Finish board optimization
2015-04-19 Control board: Fix missing not optimized track line
2015-04-25 Control board: Optimze some routes
2015-05-08 Control board: Remove the useless wire
2015-05-18 Firmware: Abandon the legacy firmware code and finish the tube control driver
2015-05-20 Firmware: Create brightness control function
2015-05-21 Firmware: Implement RTC init/print/set functions
2015-05-24 Firmware: Finish scanning display with the correct time
2015-05-25 Firmware: Fix time mode tube 2 and 5 over bright issue
2015-05-26 Firmware: Remove the infinite loop of function "clock_display"
2015-05-26 Firmware: Add serial message parsing function (support time setting command)
2015-05-26 Firmware: Replace the old RTC library with new one
2015-05-26 Firmware: Implement mode switch function
2015-11-14 [All in one]Construct mode circuits
2015-11-14 [All in one circuit]Add DS1307
2015-11-14 [All in one circuit]Arrange the USART pin
2015-11-14 [All in one]Define part of compoment's footprint
2015-11-16 [IN-14]Add IN-14 circuit
2015-11-16 [All in one]Finish the tube display circuit
2015-11-17 [All in one]Create IN-14's footprint
2015-11-17 [All in one circuit]Import IN-14 library
2015-11-23 [All in one]Add tube comma control circuit
2015-11-30 [All in one]Select footprint for capacitors
2015-11-30 [Firmware]Add tube dot control
2016-01-23 Finished select all the component footprint
2016-02-06 Finsihed placing all the components
2016-02-06 Finish the layout of power supply part
2016-04-01 Redesign the all in one board
2016-05-13 Fix mode change error
2016-05-13 Implement alarm setting function
2016-05-13 Fix EEPROM and alarm setting
2016-05-14 Implement music player
2016-05-16 FIx multiple problems
2016-05-18 Draw the layout of new display board
2016-05-30 New hardware is almost finished
2016-05-30 Create footprint common library
2016-05-30 Arrange the floder
2016-06-01 Finish the new display board
2016-06-01 Fix the battery set
2016-06-01 Control board is almost finished
2016-06-02 Add gerber file
2016-06-03 Eliminate display borads layer
2016-06-03 Elimanate control board to 2 layers only
2016-06-03 Forgot to commit this one
2016-06-29 Store the externel module
2016-07-02 Fix RTC
2016-07-02 Fix pindef
2016-07-05 Fix RTC to be more accurate
2016-07-08 Add atmega328p-au pinout
2016-07-08 Use ISR handle the clock display function
2016-07-11 Test alarm on new board
2016-07-14 Implement more bluetooth commands
2016-07-23 Implement mp3 loop play function
2016-07-23 Implement music volume eeprom hack
2016-07-24 Create interface for hibernation, implement alarm sound control
2016-07-24 Implement hibernation time check
2016-07-27 First stable version
2016-07-27 Add USART timeout mechanism
2016-07-31 Add some marks
2016-07-31 Fix firmware multiple bugs
2016-08-03 Fix music random play, button debounce and hibernation check
2016-08-04 Fix hibernation time check
2016-08-04 Create hacked font table
2016-08-04 Add AltSoftwareSerial version DFPlayer driver
2016-08-04 Fix Software serial ISRT priority issue
2016-08-07 Fix loop play check
2016-08-07 Layout need to be arranged, scheme is finished
2016-08-07 Add music command ack
2016-08-07 Add demo pictures
2016-09-07 Add display board doc
2016-09-12 Add ratio extender circuit
2016-09-13 Update commertial board
2017-02-01 Add tube hack
2017-02-01 Fix freecad
2017-02-01 Fix mp3
2017-02-01 Fix PCB board
2017-02-02 Fix board errors
2017-06-27 Extend keep out zone
2018-01-05 Give part name (D_Schotkky)
2018-04-22 Arrange directory's name
